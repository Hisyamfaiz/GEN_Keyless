# Keil uVision project enhanced_shockburst_ptx_nrf24le1.uvproj, settings and files
target PTX (MCS-51)
  device: nRF24LE1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) XRAM2(0xFA00-0xFFFF) CLOCK(24000000) MODDP2
  output: enhanced_shockburst_ptx_nrf24le1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: MCU_NRF24LE1
  c include: ..\..\..\..\..\..\hal\nrf24le1;..\..\..\..\..\..\hal\nrf24l01p;..\..\..\..\..\..\hal;..\..\..\..\..\..\compiler\c51;..\..\..\..\..\..\compiler\common
  group App
    ../../: main.c
  group HAL
    ../../../../../../hal/nrf24le1/: hal_nrf_hw.c hal_clk.c hal_aes.c hal_flash.c hal_wdog.c hal_rtc.c hal_rng.c
    ../../../../../../hal/nrf24l01p/: hal_nrf.c
    ../../../../../../hal/: hal_delay.c
